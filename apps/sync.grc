<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/rx.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/dvb_res_today.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>10240</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>3024</value></param>
</block>
<block>
<key>dtv_dvbt_convolutional_deinterleaver</key>
<param><key>id</key><value>dtv_dvbt_convolutional_deinterleaver_0</value></param>
<param><key>blocks</key><value>136</value></param>
<param><key>M</key><value>17</value></param>
<param><key>I</key><value>12</value></param>
</block>
<block>
<key>dtv_dvbt_energy_descramble</key>
<param><key>id</key><value>dtv_dvbt_energy_descramble_0</value></param>
<param><key>nsize</key><value>8</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_dec</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_dec_0</value></param>
<param><key>blocks</key><value>8</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>dvbt_rx_demap</key>
<param><key>id</key><value>dvbt_rx_demap_0</value></param>
</block>
<block>
<key>dvbt_rx_gpu_viterbi</key>
<param><key>id</key><value>dvbt_rx_gpu_viterbi_0</value></param>
</block>
<block>
<key>dvbt_rx_superframe</key>
<param><key>id</key><value>dvbt_rx_superframe_0</value></param>
</block>
<block>
<key>dvbt_rx_sync_cc</key>
<param><key>id</key><value>dvbt_rx_sync_cc_0</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dvbt_rx_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>dvbt_rx_superframe_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_convolutional_deinterleaver_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_energy_descramble_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_dec_0</source_block_id><sink_block_id>dtv_dvbt_energy_descramble_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_rx_demap_0</source_block_id><sink_block_id>dvbt_rx_gpu_viterbi_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_rx_gpu_viterbi_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_rx_superframe_0</source_block_id><sink_block_id>dtv_dvbt_convolutional_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_rx_sync_cc_0</source_block_id><sink_block_id>dvbt_rx_demap_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_rx_sync_cc_0</source_block_id><sink_block_id>dvbt_rx_demap_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
