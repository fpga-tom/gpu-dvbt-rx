<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/dvb_res_today.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>10240</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>18144</value></param>
</block>
<block>
<key>dvbt_rx_demap</key>
<param><key>id</key><value>dvbt_rx_demap_0</value></param>
</block>
<block>
<key>dvbt_rx_gpu_viterbi</key>
<param><key>id</key><value>dvbt_rx_gpu_viterbi_0</value></param>
</block>
<block>
<key>dvbt_rx_sync_cc</key>
<param><key>id</key><value>dvbt_rx_sync_cc_0</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dvbt_rx_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_rx_demap_0</source_block_id><sink_block_id>dvbt_rx_gpu_viterbi_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_rx_gpu_viterbi_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_rx_sync_cc_0</source_block_id><sink_block_id>dvbt_rx_demap_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt_rx_sync_cc_0</source_block_id><sink_block_id>dvbt_rx_demap_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
